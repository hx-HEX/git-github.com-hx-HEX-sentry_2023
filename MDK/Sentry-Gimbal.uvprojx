# Keil uVision project Sentry-Gimbal.uvprojx, settings and files
target Sentry-Gimbal (ARM-GNU)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IROM(0x08000000,0x00100000) IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Sentry-Gimbal +hex
  group Bsp
    ../Bsp/bmi088/: bmi088.cpp bmi088.h bmi088reg.h
    ../Bsp/communication/: can_interface.cpp can_interface.h communication.cpp communication.h retarget.c retarget.h uart_interface.cpp uart_interface.h
    ../Bsp/encoder/: encoder.cpp encoder.h
    ../Bsp/gimbal/: gimbal.cpp gimbal.h
    ../Bsp/gpio/: led.cpp led.h
    ../Bsp/vofa/: vofa.cpp vofa.h
  group Core
    ../Core/Src/: can.c dma.c gpio.c main.c spi.c stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c tim.c usart.c
    ../Core/Inc/: can.h dma.h gpio.h main.h spi.h stm32f4xx_hal_conf.h stm32f4xx_it.h tim.h usart.h
  group Middlewares
    ../Middlewares/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/FreeRTOS/portable/GCC/ARM_CM4F/: port.c portmacro.h
    ../Middlewares/FreeRTOS/portable/MemMang/: heap_4.c
    ../Middlewares/FreeRTOS/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group Drivers
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Include/: stm32f4xx.h stm32f405xx.h system_stm32f4xx.h
    ../Drivers/CMSIS/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm3.h core_cm4.h core_cm7.h core_cm23.h core_cm33.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h tz_context.h
    ../Drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal.h stm32f4xx_hal_can.h stm32f4xx_hal_cortex.h stm32f4xx_hal_def.h stm32f4xx_hal_dma.h stm32f4xx_hal_dma_ex.h stm32f4xx_hal_exti.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h stm32f4xx_hal_flash_ramfunc.h stm32f4xx_hal_gpio.h stm32f4xx_hal_gpio_ex.h stm32f4xx_hal_pwr.h stm32f4xx_hal_pwr_ex.h stm32f4xx_hal_rcc.h stm32f4xx_hal_rcc_ex.h stm32f4xx_hal_spi.h stm32f4xx_hal_tim.h stm32f4xx_hal_tim_ex.h stm32f4xx_hal_uart.h stm32f4xx_ll_bus.h stm32f4xx_ll_cortex.h stm32f4xx_ll_dma.h stm32f4xx_ll_exti.h stm32f4xx_ll_gpio.h stm32f4xx_ll_pwr.h stm32f4xx_ll_rcc.h stm32f4xx_ll_system.h stm32f4xx_ll_tim.h stm32f4xx_ll_usart.h stm32f4xx_ll_utils.h
    ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Robot
    ../Robot/actuators/: gm6020.cpp gm6020.h m2006.cpp m2006.h m3508.cpp m3508.h
    ../Robot/algorithms/: adrc.cpp adrc.h pid.cpp pid.h common_math.cpp common_math.h kalman.cpp kalman.h mahony.cpp mahony.h smc.cpp smc.h
    ../Robot/instances/: sentry_robot.cpp sentry_robot.h
  group startup
    ../startup/: startup_stm32f405xx.s
  group UserApp
    ../UserApp/config/: FreeRTOSConfig.h
    ../UserApp/: common_inc.h system_monitor.h user_callback.cpp user_callback.h user_global.cpp user_global.h user_main.cpp user_main.h user_task.cpp user_task.h
    ../UserApp/protocol/: can_protocol.cpp can_protocol.h uart_protocol.cpp uart_protocol.h
